# Keil uVision project Template.uvprojx, settings and files
target STM32F407 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F407VE STMicroelectronics
  pack: Keil.STM32F4xx_DFP.1.0.8
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Template +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c include: ..\FWLIB\inc;..\USER;..\CORE;..\BSP;..\UTILS;..\CMSIS;..\STARTUP;..\STDLIB;..\FWLIB\inc;..\FWLIB\src
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group STARTUP
    ../STARTUP/: startup_stm32f40xx.s
  group CMSIS
    ../CMSIS/: system_stm32f4xx.c
  group STDLIB
    ../STDLIB/: misc.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_usart.c stm32f4xx_adc.c stm32f4xx_tim.c
  group BSP
    ../BSP/: ir_send.c ir_send.h usart.c usart.h ir_recv.c ir_recv.h
  group USER
    ./: main.c stm32f4xx_it.c
  group UTILS
    ../UTILS/: utils.c delay.c
